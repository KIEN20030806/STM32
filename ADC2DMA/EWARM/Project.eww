<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ADC2DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>
